# Keil uVision project Project.uvprojx, settings and files
target STM32F407VET6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F407VET6
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --C99
  c include: ../;../../../Libraries/CMSIS/Include;../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../Middlewares/FreeRTOS/Source/include;../../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../Core;../../../BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: system_stm32f4xx.c freertos_hooks.c
    ../../../Core/: stm32f4xx_it.c main.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group FreeRTOS
    ../../../Middlewares/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group BSP
    ../../../BSP/: My_Led.c My_Led.h My_USART.c My_USART.h My_ADC_DMA.c My_ADC_DMA.h My_Button.c My_Button.h
